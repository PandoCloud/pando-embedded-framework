# Keil uVision project stm32_gprs_1.0.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_gprs_1.0
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\sys\driver\STM32F10x_StdPeriph_Lib\STM32F10x_StdPeriph_Driver;..\sys\driver\STM32F10x_StdPeriph_Lib\CMSIS\CM3\CoreSupport;..\sys\driver\STM32F10x_StdPeriph_Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\sys\driver\STM32F10x_StdPeriph_Lib\STM32F10x_StdPeriph_Driver\inc;..\framework\platform\include;..\framework;..\framework\protocol;..\framework\subdevice
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group example
    F:/gateway-gprs/example/stm32/: main.c
  group framework
    F:/gateway-gprs/framework/gateway/: pando_channel.c pando_cloud_access.c pando_device_login.c pando_device_register.c pando_gateway.c pando_storage_interface.c pando_zero_device.c
    F:/gateway-gprs/framework/lib/json/: jsonparse.c jsontree.c
    F:/gateway-gprs/framework/protocol/: common_functions.c pando_endian.c pando_machine.c pando_protocol.c sub_device_protocol.c
    F:/gateway-gprs/framework/subdevice/: pando_object.c pando_subdevice.c
    F:/gateway-gprs/framework/: pando_framework.c
